Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2017-06-22T13:59:19
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jun 22 13:59:19 2017 * Host: DESKTOP-2T2TN3Q * Database: C:\Users\PC009\AppData\Local\Temp\{761C6A55-0867-4BE5-A6D5-2CA78276CF3A}\ifc * Database version: 5507 * Database creation date: Thu Jun 22 13:59:17 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jun 22 13:59:17 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jun 22 13:59:17 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 40, 24, 0, 5493; RefLongitude: -3, -40, -59, -880065; RefElevation: 0 m

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Nivel 1
LongName: Nivel 1; Elevation: 0 m

# IfcCurtainWall: Muro cortina:Muro cortina - simple, Muro cortina:Muro cortina - simple:157639
In: Nivel 1
Pset_CurtainWallCommon - Reference: Muro cortina - simple; IsExternal: yes

# IfcPlate: HI-PIRM STS 50, HI-PIRM STS_H:50 mm:157683
In: Nivel 1
Type - ElementType: 50 mm; PredefinedType: CURTAIN_PANEL; Material: Huurre_Panel
Pset_PlateCommon - IsExternal: yes; Reference: 50 mm; LoadBearing: yes
